# Repository 8bitgeek/geektag

File README.md:

# geektag
GEEKTAG OpenOCD Compatible FT232RL USB JTAG Debugger 

** In Development **

## KiCad design pa-jtag.kicad_pcb

Board: 4 copper layers, 83.8 x 31.8 mm, 69 parts (0 on the bottom side), 73 nets, no tracks yet.

Parts:
C1: 10nF; C_0603_1608Metric
C2, C16: 6.8uF; CP_EIA-3216-18_Kemet-A
C3, C4, C5, C6, C7, C9, C11, C12, C13, C14, C15, C17, C18: 100nF; C_0603_1608Metric
C8, C10: 20pF; C_0603_1608Metric
D1: VBUS; LED_0603_1608Metric
D2, D3, D4, D6, D10, D11: NUP2105L; SOT-23
D5, D7: 1N4148; D_MiniMELF
D8: ST1; LED_0603_1608Metric
D9: ST0; LED_0603_1608Metric
J1: USB_B; USB_Mini-B_Wuerth_65100516121_Horizontal
J2: RS232; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_H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
J4: VOUT; PinHeader_1x03_P2.54mm_Horizontal
J5: AUX; PinHeader_2x05_P2.54mm_Horizontal
J7: SWD/SERIAL; PinHeader_2x06_P2.54mm_Horizontal
J8: CH_SWD; PinHeader_1x06_P2.54mm_Vertical
J9: JTAG; PinHeader_2x10_P2.54mm_Horizontal
J10: VCCIO; PinHeader_2x03_P2.54mm_Horizontal
L1: 10uH; L_0805_2012Metric
R1, R10, R11: 470; R_0603_1608Metric
R2, R3, R4, R5, R6, R7, R8, R9, R23, R24, R25, R26: 10R; R_0603_1608Metric
R12, R13, R17, R19, R20, R21, R22: 10K; R_0603_1608Metric
R14, R15: 4K7; R_0603_1608Metric
R16: 0R; R_0603_1608Metric
R18: 100R; R_0603_1608Metric
SW1: RESET; SW_SPST_CK_RS282G05A3
U1: MAX3232; SOIC-16_3.9x9.9mm_P1.27mm
U2: L78L33_TO92; TO-92_Inline
U3: CH32V103C8T6; LQFP-48_7x7mm_P0.5mm
Y1: 8M; Crystal_HC49-4H_Vertical

Connections:
+3V3: C4.1, J4.1, J5.1, U2.1 (VO)
+5V: C2.1, D1.2 (A), J4.3, J5.2, L1.2, U2.3 (VI)
+VSW: C3.1, C7.1, C11.1, C12.1, C13.1, C14.1, C16.1, J8.1, J10.3, R12.1, R13.1, R14.1, R15.1, R17.1, R19.1, R20.1, R21.1, R22.1, U1.16 (VCC), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD)
/AUX0: J5.10, U3.17 (PA7)
/AUX1: J5.9, U3.29 (PA8)
/AUX2: J5.8, U3.30 (PA9)
/AUX3: J5.7, U3.18 (PB0)
/AUX4: J5.6, U3.19 (PB1)
/AUX5: J5.5, U3.45 (PB8)
/AUX6: J5.4, U3.46 (PB9)
/BOOT1: R16.1, U3.20 (PB2)
/CH_NRST: C15.1, J8.5, R17.2, SW1.1, U3.7 (NRST)
/CH_SWCLK: J8.2, U3.38 (PA15)
/CH_SWDIO: J8.4, U3.34 (PA13)
/CH_SWO: J8.6, U3.39 (PB3)
/CTS: J2.7, U1.8 (R2IN)
/I2C_SCL: J7.8, R14.2, U3.42 (PB6)
/I2C_SDA: J7.10, R15.2, U3.43 (PB7)
/MCU-SRST: D4.1 (K), R9.2, R19.2, U3.40 (PB4)
/MCU-TCK: D3.1 (K), R4.2, R13.2, U3.26 (PB13)
/MCU-TDI: D2.1 (K), R5.2, R12.2, U3.27 (PB14)
/MCU-TDO: D4.2 (K), R6.2, R22.2, U3.28 (PB15)
/MCU-TMS: D3.2 (K), R7.2, R21.2, U3.25 (PB12)
/MCU-TRST: D2.2 (K), R8.2, R20.2, U3.41 (PB5)
/MCU_RS232_CTS: U1.9 (R2OUT), U3.10 (PA0)
/MCU_RS232_RTS: U1.10 (T2IN), U3.11 (PA1)
/MCU_RS232_RX: U1.12 (R1OUT), U3.13 (PA3)
/MCU_RS232_TX: U1.11 (T1IN), U3.12 (PA2)
/MCU_SWCLK: D11.2 (K), R23.2, U3.15 (PA5)
/MCU_SWDIO: D11.1 (K), R18.1, R24.2, U3.16 (PA6)
/MCU_SWDIO_PUD: R18.2, U3.14 (PA4)
/MCU_SWNRST: D10.1 (K), R26.2, U3.37 (PA14)
/MCU_SWO: D10.2 (K), R25.2, U3.31 (PA10)
/NRST: J7.9, R26.1
/RTS: J2.8, U1.7 (T2OUT)
/RXD: J2.3, U1.13 (R1IN)
/SRST: J9.15, R9.1
/ST0: D8.2 (A), U3.3 (PC14)
/ST1: D9.2 (A), U3.4 (PC15)
/SWCLK: J7.3, R23.1
/SWDIO: J7.7, R24.1
/SWO: J7.11, R25.1
/TCK: J9.9, R4.1
/TDI: J9.5, R5.1
/TDO: J9.13, R6.1
/TMS: J9.7, R7.1
/TRST: J9.3, R8.1
/TXD: J2.2, U1.14 (T1OUT)
/UART_RX: J7.4, U3.22 (PB11)
/UART_TX: J7.2, U3.21 (PB10)
/UD+: R2.1, U3.33 (PA12)
/UD-: R3.1, U3.32 (PA11)
/VOUT: D5.2 (A), J4.2, J10.1
/VOUTR: D5.1 (K), J9.2, J10.2
/VSWD: C17.1, J7.1, J10.4
/VTARGET: J9.1, J10.5, J10.6
/VUSB: C1.1, D7.1 (K), L1.1
GND: C1.2, C2.2, C3.2, C4.2, C6.1, C7.2, C8.1, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.1, D2.3 (A), D3.3 (A), D4.3 (A), D6.3 (A), D10.3 (A), D11.3 (A), J1.4 (GND), J1.5 (Shield), J2.0 (PAD), J2.5, J5.3, J7.5, J7.6, J7.12, J8.3, J9.4, J9.6, J9.8, J9.10, J9.12, J9.14, J9.16, J9.18, J9.20, R1.2, R10.2, R11.2, R16.2, SW1.2, U1.15 (GND), U2.2 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.44 (BOOT0), U3.47 (VSS)
unnamed: C18.2, U1.6 (VS-)
unnamed: D1.1 (K), R1.1
unnamed: D7.2 (A), J1.1 (VBUS)
unnamed: D8.1 (K), R10.1
unnamed: D9.1 (K), R11.1
unnamed: D6.1 (K), J1.3 (D+), R2.2
unnamed: D6.2 (K), J1.2 (D-), R3.2
unnamed: J2.1, J2.4, J2.6
unnamed: C9.2, U1.1 (C1+)
unnamed: C9.1, U1.3 (C1-)
unnamed: C5.1, U1.4 (C2+)
unnamed: C5.2, U1.5 (C2-)
unnamed: C6.2, U1.2 (VS+)
unnamed: C10.2, U3.5 (PD0), Y1.2
unnamed: C8.2, U3.6 (PD1), Y1.1

## Commit log

2022-03-01 Add J5 and Open Drain Resets
2022-07-27 ch32 initial commit
2022-07-28 ch32v103 jtag schematic
2022-07-29 ch32v103c schematic / placement
